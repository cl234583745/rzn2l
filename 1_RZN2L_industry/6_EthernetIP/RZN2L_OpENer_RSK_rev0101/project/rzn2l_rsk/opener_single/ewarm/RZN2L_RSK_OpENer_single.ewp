# IAR project RZN2L_RSK_OpENer_single.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G084M08 Renesas R9A07G084M08
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _RENESAS_RZN_
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/rm_freertos_port; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; ..\..\..\..\common\oss\lwip\src\include; ..\..\..\..\common\oss\lwip\src\include\compat\posix; ..\..\..\..\common\oss\amazon-freertos\libraries\3rdparty\lwip_osal\include; ..\..\..\..\common\renesas\oss_deps\lwip; ..\..\..\..\common\renesas\module\ether_netif; ..\..\..\..\common\renesas\module\lwip_port; ..\..\..\..\common\renesas\module\serial_io; ..\..\..\..\common\renesas\module; ..\..\..\..\common\oss\OpENer\source\src; ..\..\..\..\common\oss\OpENer\source\src\cip; ..\..\..\..\common\oss\OpENer\source\src\enet_encap; ..\..\..\..\common\oss\OpENer\source\src\utils; ..\..\..\..\common\renesas\module\opener_port; ..\..\..\..\common\renesas\module\dlr; ..\..\..\..\common\renesas\oss_deps\opener; ..\..\..\..\common\renesas\application
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RENESAS_RZN_
  AARM.AUserIncludes: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/rm_freertos_port; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src
  OBJCOPY.OOCOutputFile: RZN2L_RSK_OpENer_single.srec
  postbuild: cmd /c ""$RASC_EXE_PATH$" -nosplash --launcher.suppressErrors --gensmartbundle --compiler IAR --devicefamily rzn "configuration.xml" "$TARGET_PATH$" 2> "%TEMP%\rasc_stderr.out""
  ILINK.IlinkOutputFile: RZN2L_RSK_OpENer_single.out
  ILINK.IlinkIcfFile: script/fsp_ram_execution.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RENESAS_RZN_
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ./: buildinfo.ipcf
  group common/oss/amazon-freertos/lwip_osal
    ../../../../common/oss/amazon-freertos/libraries/3rdparty/lwip_osal/include/arch/: cc.h perf.h sys_arch.h
    ../../../../common/oss/amazon-freertos/libraries/3rdparty/lwip_osal/include/: lwipopts_freertos.h
    ../../../../common/oss/amazon-freertos/libraries/3rdparty/lwip_osal/src/: sys_arch.c
  group common/oss/lwip/api
    ../../../../common/oss/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group common/oss/lwip/core
    ../../../../common/oss/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group common/oss/lwip/core/ipv4
    ../../../../common/oss/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group common/oss/lwip/netif
    ../../../../common/oss/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c FILES lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group common/oss/lwip/netif/ppp
    ../../../../common/oss/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c PPPD_FOLLOWUP pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group common/oss/lwip/netif/ppp/polarssl
    ../../../../common/oss/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c README sha1.c
  group common/oss/OpENer
    ../../../../common/oss/OpENer/source/src/: opener_api.h trace.h typedefs.h
  group common/oss/OpENer/cip
    ../../../../common/oss/OpENer/source/src/cip/: appcontype.c appcontype.h cipassembly.c cipassembly.h cipclass3connection.c cipclass3connection.h cipcommon.c cipcommon.h cipconnectionmanager.c cipconnectionmanager.h cipconnectionobject.c cipconnectionobject.h cipdlr.c cipdlr.h cipelectronickey.c cipelectronickey.h cipepath.c cipepath.h ciperror.h cipethernetlink.c cipethernetlink.h cipidentity.c cipidentity.h cipioconnection.c cipioconnection.h cipmessagerouter.c cipmessagerouter.h cipqos.c cipqos.h cipstring.c cipstring.h ciptcpipinterface.c ciptcpipinterface.h ciptypes.h CMakeLists.txt
  group common/oss/OpENer/enet_encap
    ../../../../common/oss/OpENer/source/src/enet_encap/: CMakeLists.txt cpf.c cpf.h encap.c encap.h endianconv.c endianconv.h
  group common/oss/OpENer/utils
    ../../../../common/oss/OpENer/source/src/utils/: CMakeLists.txt doublylinkedlist.c doublylinkedlist.h enipmessage.c enipmessage.h random.c random.h xorshiftrandom.c xorshiftrandom.h
  group common/renesas/application
    ../../../../common/renesas/application/: board_io_define.h opener_port_instance.c opener_port_main.c
  group common/renesas/module
    ../../../../common/renesas/module/: um_common_api.h um_common_cfg.h
  group common/renesas/module/dlr
    ../../../../common/renesas/module/dlr/: r_ethsw_extend.c r_ethsw_extend.h r_ethsw_extend_api.h um_dlr.c um_dlr.h um_dlr_api.h um_dlr_cfg.h um_dlr_ether_netif.c um_dlr_ether_switch.c um_dlr_fsm.c um_dlr_fsm_frame.c um_dlr_fsm_frame.h um_dlr_internal.h um_dlr_task_executor.c um_dlr_task_receiver.c um_dlr_timer_neighbor_checker.c
  group common/renesas/module/ether_netif
    ../../../../common/renesas/module/ether_netif/: um_ether_netif.c um_ether_netif.h um_ether_netif_api.h um_ether_netif_callback.c um_ether_netif_cfg.h um_ether_netif_ether.c um_ether_netif_feature.h um_ether_netif_internal.h um_ether_netif_task_monitor.c um_ether_netif_task_reader.c um_ether_netif_task_writer.c
  group common/renesas/module/lwip_port
    ../../../../common/renesas/module/lwip_port/: um_lwip_port.c um_lwip_port.h um_lwip_port_api.h um_lwip_port_callback.c um_lwip_port_cfg.h um_lwip_port_core.c um_lwip_port_ether_netif.c um_lwip_port_internal.h um_lwip_port_netif.c um_lwip_port_netif_list.c um_lwip_port_task_launcher.c um_lwip_port_task_receiver.c
  group common/renesas/module/opener_port
    ../../../../common/renesas/module/opener_port/: um_opener_port.c um_opener_port.h um_opener_port_api.h um_opener_port_callback.c um_opener_port_cfg.h um_opener_port_cip.c um_opener_port_dlr.c um_opener_port_encap.c um_opener_port_ether_netif.c um_opener_port_feature.h um_opener_port_internal.h um_opener_port_lwip_port.c um_opener_port_task_indicator.c um_opener_port_task_netif.c um_opener_port_tcpip_netif.c
  group common/renesas/module/serial_io
    ../../../../common/renesas/module/serial_io/: um_serial_io.c um_serial_io.h um_serial_io_api.h um_serial_io_cfg.h um_serial_io_internal.h um_serial_io_task_writer.c um_serial_io_uart.c
  group common/renesas/oss_deps/lwip
    ../../../../common/renesas/oss_deps/lwip/: lwipopts.h
  group common/renesas/oss_deps/opener
    ../../../../common/renesas/oss_deps/opener/: devicedata.h generic_networkhandler.h networkhandler.h opener_error.h opener_user_conf.h platform_network_includes.h socket_timer.c socket_timer.h
  group common/renesas/oss_deps/opener/netinet
    ../../../../common/renesas/oss_deps/opener/netinet/: in.h
  group Flex Software/Build Configuration
    rzn_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    rzn_cfg/aws/: FreeRTOSConfig.h
    rzn_cfg/fsp_cfg/: r_ether_cfg.h r_ether_phy_cfg.h r_ether_selector_cfg.h r_ethsw_cfg.h r_ioport_cfg.h r_sci_uart_cfg.h
  group Flex Software/Components
    rzn/aws/amazon-freertos/freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    rzn/board/rzn2l_rsk/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    rzn/fsp/inc/api/: bsp_api.h r_ether_api.h r_ether_phy_api.h r_ether_selector_api.h r_ethsw_api.h r_ioport_api.h r_transfer_api.h r_uart_api.h
    rzn/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_tfu.h
    rzn/fsp/src/bsp/mcu/rzn2l/: bsp_elc.h bsp_feature.h bsp_loader_param.c bsp_mcu_info.h
    rzn/arm/CMSIS_5/CMSIS/Core_R/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cr52.h
    rzn/aws/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    rzn/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    rzn/aws/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
    rzn/aws/amazon-freertos/: LICENSE
    rzn/arm/CMSIS_5/: LICENSE.txt
    rzn/aws/amazon-freertos/freertos_kernel/License/: license.txt
    rzn/fsp/src/rm_freertos_port/: port.c portmacro.h
    rzn/fsp/src/r_ether_phy/: r_ether_phy.c
    rzn/fsp/inc/instances/: r_ether_phy.h r_ether_selector.h r_ethsw.h r_gmac.h r_ioport.h r_sci_uart.h
    rzn/fsp/src/r_ether_selector/: r_ether_selector.c
    rzn/fsp/src/r_ethsw/: r_ethsw.c
    rzn/fsp/src/r_gmac/: r_gmac.c
    rzn/fsp/src/r_ioport/: r_ioport.c
    rzn/fsp/src/r_sci_uart/: r_sci_uart.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/SVD/: RA.svd
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Include/: renesas.h system.h
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    rzn_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c main_thread.c main_thread.h pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c main_thread_entry.c
