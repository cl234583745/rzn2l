# IAR project RZN2L_RSK_Modbus_TCP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G084M08 Renesas R9A07G084M08
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _RENESAS_RZN_
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/rm_freertos_port; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; ..\..\..\..\common\renesas\modbus\include; ..\..\..\..\common\renesas\modbus_user; rzn/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/include; rzn/fsp/src/rm_freertos_plus_tcp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RENESAS_RZN_
  AARM.AUserIncludes: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/aws/amazon-freertos/freertos_kernel/include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn/fsp/src/rm_freertos_port; rzn_cfg/aws; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src; rzn/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/include; rzn/fsp/src/rm_freertos_plus_tcp
  postbuild: cmd /c ""$RASC_EXE_PATH$" -nosplash --launcher.suppressErrors --gensmartbundle --compiler IAR --devicefamily rzn "configuration.xml" "$TARGET_PATH$" 2> "%TEMP%\rasc_stderr.out""
  ILINK.IlinkOutputFile: RZN2L_RSK_Modbus_TCP.out
  ILINK.IlinkIcfFile: script/fsp_ram_execution.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RENESAS_RZN_
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    rzn_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    rzn_cfg/aws/: FreeRTOSConfig.h FreeRTOSIPConfig.h
    rzn_cfg/fsp_cfg/: r_ether_cfg.h r_ether_phy_cfg.h r_ether_selector_cfg.h r_ethsw_cfg.h r_ioport_cfg.h
  group Flex Software/Components
    rzn/aws/amazon-freertos/freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    rzn/board/rzn2l_rsk/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    rzn/fsp/inc/api/: bsp_api.h r_ether_api.h r_ether_phy_api.h r_ether_selector_api.h r_ethsw_api.h r_ioport_api.h
    rzn/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_tfu.h
    rzn/fsp/src/bsp/mcu/rzn2l/: bsp_elc.h bsp_feature.h bsp_loader_param.c bsp_mcu_info.h
    rzn/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/source/portable/BufferManagement/: BufferAllocation_2.c
    rzn/arm/CMSIS_5/CMSIS/Core_R/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cr52.h
    rzn/aws/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    rzn/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/source/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
    rzn/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/include/: FreeRTOS_ARP.h FreeRTOS_DHCP.h FreeRTOS_DNS.h FreeRTOS_errno_TCP.h FreeRTOS_IP.h FreeRTOS_IP_Private.h FreeRTOS_Sockets.h FreeRTOS_Stream_Buffer.h FreeRTOS_TCP_IP.h FreeRTOS_TCP_WIN.h FreeRTOS_UDP_IP.h FreeRTOSIPConfigDefaults.h IPTraceMacroDefaults.h NetworkBufferManagement.h NetworkInterface.h tcp_dump_packets.h tcp_mem_stats.h
    rzn/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    rzn/aws/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
    rzn/aws/amazon-freertos/: LICENSE
    rzn/arm/CMSIS_5/: LICENSE.txt
    rzn/aws/amazon-freertos/freertos_kernel/License/: license.txt
    rzn/fsp/src/rm_freertos_plus_tcp/: NetworkInterface.c pack_struct_end.h pack_struct_start.h
    rzn/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/source/portable/Compiler/GCC/: pack_struct_end.h pack_struct_start.h
    rzn/aws/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_tcp/source/portable/Compiler/IAR/: pack_struct_end.h pack_struct_start.h
    rzn/fsp/src/rm_freertos_port/: port.c portmacro.h
    rzn/fsp/src/r_ether_phy/: r_ether_phy.c
    rzn/fsp/inc/instances/: r_ether_phy.h r_ether_selector.h r_ethsw.h r_gmac.h r_ioport.h
    rzn/fsp/src/r_ether_selector/: r_ether_selector.c
    rzn/fsp/src/r_ethsw/: r_ethsw.c
    rzn/fsp/src/r_gmac/: r_gmac.c
    rzn/fsp/src/r_ioport/: r_ioport.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/SVD/: RA.svd
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Include/: renesas.h system.h
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    rzn_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c main_thread.c main_thread.h pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: blinky_thread_entry.c hal_entry.c main_thread_entry.c
  group modbus/include
    ../../../../common/renesas/modbus/include/: modbus.h modbusCommon.h modbusTypedef.h
  group modbus/include/port
    ../../../../common/renesas/modbus/include/port/: modbusPortMalloc.h modbusPortRtos.h modbusPortTcp.h
  group modbus/include/slave
    ../../../../common/renesas/modbus/include/slave/: modbusSlave.h
  group modbus/include/tcp
    ../../../../common/renesas/modbus/include/tcp/: modbusTcp.h modbusTcpConfig.h modbusTcpSlave.h
  group modbus/source/port
    ../../../../common/renesas/modbus/source/port/: modbusPortMalloc.c modbusPortRtos.c modbusPortTcp.c
  group modbus/source/slave
    ../../../../common/renesas/modbus/source/slave/: modbusSlave.c
  group modbus/source/tcp
    ../../../../common/renesas/modbus/source/tcp/: modbusTcp.c modbusTcpTask.c
  group modbus_user
    ../../../../common/renesas/modbus_user/: modbus_func.c modbus_init.c modbus_user.c
